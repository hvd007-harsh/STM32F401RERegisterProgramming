# Keil uVision project INTORLOCKING.uvproj, settings and files
target Target 1 (MCS-51)
  device: MS51xB9xE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x3FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: INTORLOCKING +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: D:\MS51BSP_KEIL-master\MS51FB9AE_MS51XB9AE_MS51XB9BE\Library\Device\Include;D:\MS51BSP_KEIL-master\MS51FB9AE_MS51XB9AE_MS51XB9BE\Library\StdDriver\inc
  group Source
    ./: main.c
  group Library
    ./: sys.c wdt.c
  group Startup
    ./: MS51_STARTUP.A51
